## drivers/input/touchscreen/goodix/Kconfig
```kconfig
source "drivers/input/touchscreen/goodix/brl/Kconfig"
source "drivers/input/touchscreen/goodix/gt738x/Kconfig"
```
